# IAR project RDW3A-IMU-V1.1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1225 NXP LPC1225
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\Common\Core\CM0\CoreSupport; ..\Common\Core\CM0\DeviceSupport\NXP\LPC12xx; ..\Common\Drivers\include; inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RDW3A-IMU-V1.1.srec
  ILINK.IlinkOutputFile: RDW3A-IMU-V1.1.out
  ILINK.IlinkIcfFile: F:\MCUPROGRAM\NXP\LPC12XX\project\RDW3A-IMU\RDW3A-IMU-V1.1\config\LPC1227_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../Common/Core/CM0/CoreSupport/: core_cm0.c core_cm0.h
    ../Common/Core/CM0/DeviceSupport/NXP/LPC12xx/startup/iar/: startup_LPC12xx.s
    ../Common/Core/CM0/DeviceSupport/NXP/LPC12xx/: system_LPC12xx.c system_LPC12xx.h
  group DEVICE
    ../Common/Drivers/source/: debug_frmwrk.c lpc12xx_adc.c lpc12xx_comp.c lpc12xx_crc.c lpc12xx_dma.c lpc12xx_flash.c lpc12xx_gpio.c lpc12xx_i2c.c lpc12xx_iocon.c lpc12xx_libcfg_default.c lpc12xx_pmu.c lpc12xx_rtc.c lpc12xx_ssp.c lpc12xx_sysctrl.c lpc12xx_timer16.c lpc12xx_timer32.c lpc12xx_uart.c lpc12xx_wdt.c
  group USER CODE
    src/: altitude.c datapro.c delay.c imu.c imuaccel.c imugyro.c imumagn.c init.c main.c ssp.c step.c stepangle.c symbol.c timer.c
